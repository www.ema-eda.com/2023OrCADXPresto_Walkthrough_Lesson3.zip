# Allegro board presto_tutorial.brd

Outline 100 x 50 mm; copper layers: TOP, POWERPLANE_1, BOTTOM. Coordinates in mm from the lower left corner of the outline.
Outline path: 0,50 100,50 100,0 0,0 0,50

## Design rules (mm)
constraint set DEFAULT: min track width 0.127
net group DPD: nets D+ D-

## Placement (name value [footprint] x y rotation side)
NOREF  -  [unnamed]  4 46 0 top
NOREF#2  -  [unnamed]  96 4 0 top
NOREF#3  -  [unnamed]  96 46 0 top
NOREF#4  -  [unnamed]  4 4 0 top

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
unnamed
  round 4.064 hole 3.81: (0,0)

## Nets
